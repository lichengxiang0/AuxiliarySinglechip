# Keil uVision project fly_test1.uvprojx, settings and files
target fly_test1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fly_test1 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;        ../Drivers/CMSIS/Include;        ..\Drivers\STM32_BSP_Driver\inc;        ..\USER;        ..\SYSTEM\sys;        ..\Application\Communication\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: tim.c dma.c adc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c main.c gpio.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group USER
    ../USER/: led.c my_adc.c my_pwm_input.c process.c 24cxx.c myiic.c mynop.c
    ../Src/: system_control.c
  group BSP
    ../Drivers/STM32_BSP_Driver/src/: stm32_bsp_timer.C stm32_bsp_uart.C
  group AppCom
    ../Application/Communication/src/: board_gimbal_cmd_process.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
software components: CMSIS:CORE 4.1.0
